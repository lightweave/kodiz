# Keil uVision project kodiz2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kodiz2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Config;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\kodiz
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group New Group
    ./: main.c MDR32F9Qx_board.h MDR32F9Qx_it.c MDR32F9Qx_it.h
    ./Config/: MDR32F9Qx_config.h
software components: Device:Startup 1.5, Drivers:ADC 1.5, Drivers:BKP 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
