# Keil uVision project kodiz.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kodiz
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Config;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\KODIZ
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MainSource
    ./: main.c MDR32F9Qx_it.c MDR32F9Qx_it.h
  group LibSrc
    ./Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_uart.c MDR32F9Qx_adc.c MDR32F9Qx_timer.c
    ./Config/: MDR32F9Qx_config.h
    ./: MDR32F9Qx_board.h
software components: Device:Startup 1.5
